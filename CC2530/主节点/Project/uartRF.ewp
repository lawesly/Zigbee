# IAR project uartRF.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group App
    ./: uartRF.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.c basic_rf_security.c
  group board
    ../CC2530_lib/board/: hal_board.c hal_led.c
  group common
    ../CC2530_lib/common/: hal_adc.c hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c hal_sleep.c hal_timer_32k.c hal_uart.c hal_uart1.c TIMER.c
  group utils
    ../CC2530_lib/utils/: util.c
